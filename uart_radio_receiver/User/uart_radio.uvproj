# Keil uVision project uart_radio.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uart_radio +hex
  c flags: Optim=1
  c define: NRF51
  c misc: --c99
  c include: ..\components\drivers_nrf\radio_config;..\components\drivers_nrf\hal;..\components\drivers_nrf\nrf_soc_nosd;..\components\drivers_nrf\simple_uart
  asm define: NRF51
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../Application/: main.c bps.c RTX_Config.c RTX_Conf_CM.c tasks.c
  group Device
    ../Device/: system_nrf51.c arm_startup_nrf51.s
  group nRF_Libraries
    ../components/drivers_nrf/radio_config/: radio_config.c
    ../components/drivers_nrf/hal/: nrf_delay.c
    ../components/drivers_nrf/simple_uart/: simple_uart.c
